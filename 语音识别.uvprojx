# Keil uVision project 语音识别.uvprojx, settings and files
target Voice_Rec (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-speech-recognition +hex
  AfterMake: D:\STM32\stm32-speech-recognition\Src\after-compile.bat
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Src\APP;.\Src\BSP;.\Src\GUI;.\Src\CM3_SYS;.\Src\FATFS;.\Src\StdPeriph_Driver;.\Src\StdPeriph_Driver\inc;.\Src\Speech_Recog
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./Src/APP/: main.c
  group Speech_Recog
    ./Src/Speech_Recog/: VAD.C MFCC.C DTW.C
  group GUI
    ./Src/GUI/: GUI.C
  group BSP
    ./Src/BSP/: BSP.c ADC.C delay.c Flash.C SPI.C TFTLCD.c touch_panel.c USART.C cr4_fft_1024_stm32.s spiFlash.c
  group CM3_SYS
    ./Src/CM3_SYS/: core_cm3.c
  group StdPeriph_Driver
    ./Src/StdPeriph_Driver/: stm32f10x_it.c system_stm32f10x.c
    ./Src/StdPeriph_Driver/Startup/: startup_stm32f10x_hd.s
    ./Src/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
